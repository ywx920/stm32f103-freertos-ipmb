# Keil uVision project STM32F103_FreeRTOS_LED_V1.0.uvprojx, settings and files
target STM32F103_FreeRTOS_LED_V1.0 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103RB_LED +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;.\inc;..\FreeRTOS\include;..\FreeRTOS;..\FreeRTOS\portable;..\letter-shell-master;..\lt2991;..\Ipmb;..\CMSIS;..\Bsp\SysTick;..\Bsp\I2C;..\Bsp\ADC;.\inc;..\Bsp\RESET
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group USER
    ./src/: led.c main.c stm32f10x_it.c usart.c FreeRTOS_Tasks.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Readme
    ../: Readme.txt
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group letter_shell
    ../letter-shell-master/: shell.c shell_cmd_list.c shell_ext.c shell_port.c
  group lt2991
    ../lt2991/: lt2991.c soft_i2c.c
  group IPMB
    ../Ipmb/: bsp_gpio.c bsp_i2c_slave.c ipmb_protocol.c
  group BSP
    ../Bsp/SysTick/: SysTick.c
    ../Bsp/I2C/: bsp_i2c_hw.c
    ../Bsp/ADC/: bsp_adc.c
    ../Bsp/RESET/: bsp_reset.c
software components: CMSIS:CORE 5.4.0
